Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-03-21T13:56:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 21 13:56:19 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{79C52DD5-77BB-4AD6-B113-3DDCA5E6C7D4}\ifc * Database version: 5507 * Database creation date: Mon Mar 21 13:56:17 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 21 13:56:18 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 21 13:56:18 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7412L Shower faucet with shower set, 7412L(2022):7412L Shower faucet with shower set:451531
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 81.1278 mm; FaucetNominalHeight: 63.4 mm; FaucetNominalWidth: 290 mm; HandShowerNominalDepth: 138 mm; HandShowerNominalHeight: 701 mm; HandShowerNominalWidth: 220.3 mm
Type - General - Author: BIMStone; BIMObjectName: 7412L(2020); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 18/03/2022
Type - Green Building Properties - Backflow Prevention EN1717: EB; EAN Number: 6414150097720; EN Standard: EN 1111, EN 1112, EN 1113; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4202546; RSK Number: 8283126; Sales Package dimensions (LxWxH): 745 x 241 x 82; Sales Package gross weight: 2.805 kg; Sales Package package weight: 0.47964 kg; UNSPSC Class Number: 30181800 Faucet and shower heads, jets and parts and accessories; URL Declaration of Conformity: http://static.oras.com/DoC/7412L; URL REACH: http://static.oras.com/doc/reach; VVS Number: 722780874
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7412L; Catalog Drawing URL: http://static.oras.com/catdrw/7412L; Dimension Drawing URL: http://static.oras.com/dimdrw/7412L; FDV Document URL: http://www.oras.com/datasheet/7412L/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7412L; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7412L; Interactive AR View URL: https://static.oras.com/AR/7412L; Item Type: Sales item; Manufacturer: Oras; Market: International;Norway;Sweden;Denmark; Mobile Product Information URL: http://mpi.oras.com/7412L; Model: 7412L Shower faucet with shower set; Name_en: 7412L Shower faucet with shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7412L; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7412L; Product URL: http://static.oras.com/7412L; Technical DataSheet URL: http://www.oras.com/datasheet/7412L/en; Type Name: 7412L Shower faucet with shower set; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Additional Features: lead free, < 0,1% Pb; Connection: Direct connection; Connection Size: G3/4; Flow Rate At 300kPa With Flow Controller: 0.00423776 m3/s; Hand Shower Size: Ø 70 mm; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Pressure Loss With Flow 02ls: 165000 Pa; Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Soap dish;Shower hose (1500 mm);Eco flow control; Shower Spray Number: 1 shower spray; Surface treatment: Chrome; Temperature: Thermostatic temperature control; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7412L(2022); Features: Thermostatic;; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7412L; Name: 7412L Shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 290x80x65 mm; Shower:220x140x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7412L; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7412L Shower faucet with shower set
Constraints - DistanceX-Axis: 300 mm; DistanceY-Axis: 300 mm; FaucetDefaultElevation: 900 mm; HandShowerVisibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm; ShowerDefaultElevation: 1200 mm
Dimensions - Area: 0.332258 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.022833 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7412L(2022): 7412L Shower faucet with shower set; Family and Type: 7412L(2022): 7412L Shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7412L(2022): 7412L Shower faucet with shower set; Type Id: 7412L(2022): 7412L Shower faucet with shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
